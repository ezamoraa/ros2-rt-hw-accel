FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://patch-6.1-rc7-rt5-xlnx.patch"
